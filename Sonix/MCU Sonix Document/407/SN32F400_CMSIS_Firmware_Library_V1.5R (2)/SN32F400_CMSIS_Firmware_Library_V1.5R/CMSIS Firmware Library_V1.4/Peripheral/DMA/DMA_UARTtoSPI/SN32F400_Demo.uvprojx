# Keil uVision project SN32F400_Demo.uvprojx, settings and files
target SN32F400 (6140000::V6.14::ARMCLANG)
  device: SN32F407F SONiX
  pack: SONiX.SN32F4_DFP.1.0.8
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SN32F400 +hex
  AfterMake: HexConvert.exe SN32F400 "#H"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x7ffc
  memory RVCT9: RAM 0x20000000 size 0x2000
  group UserApp
    ./: main.c PFPA.c
  group Utility
    ./Utility/: Utility.c
  group DMA
    ./Interface/DMA/: DMA.c
  group UART
    ./Interface/UART/: UART0.c UART1.c
  group SPI
    ./Interface/SPI/: SPI0.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
