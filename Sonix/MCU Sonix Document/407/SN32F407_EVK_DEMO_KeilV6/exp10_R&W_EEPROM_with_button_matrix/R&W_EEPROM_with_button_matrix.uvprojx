# Keil uVision project R&W_EEPROM_with_button_matrix.uvprojx, settings and files
target Target 1 (::::)
  device: SN32F407F SONiX
  pack: SONiX.SN32F4_DFP.1.1.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: exp1_LED_blink +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x7ffc
  memory RVCT9: RAM 0x20000000 size 0x2000
  group UserAPP
    ./Source/UserAPP/: main.c
  group Driver
    ./Source/Driver/: PFPA.c GPIO.c WDT.c Utility.c CT16B1.c I2C0.c
  group Module
    ./Source/Module/: KeyScan.c EEPROM.c Segment.c
  group Readme
    ./Source/Readme/: readme.txt
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.1
