# Keil uVision project freertos.uvprojx, settings and files
target freertos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: freertos +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o freertos.bin .\Objects\freertos.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\library\libraries\cmsis\cm3\core_support\mdk;..\..\..\library\libraries\cmsis\cm3\device_support;..\..\..\library\libraries\drivers\inc;..\..\..\library\middlewares\uart;..\..\..\library\middlewares\gpio;..\..\..\library\middlewares\3rd_party\freertos\include;..\..\..\library\middlewares\3rd_party\freertos\portable\MDK\cm3;..\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ../src/: gw1ns4c_it.c main.c
  group driver
    ../../../library/libraries/drivers/src/: gw1ns4c_gpio.c gw1ns4c_uart.c gw1ns4c_misc.c
  group cmsis
    ../../../library/libraries/cmsis/cm3/core_support/mdk/: core_cm3.c
    ../../../library/libraries/cmsis/cm3/device_support/: system_gw1ns4c.c
    ../../../library/libraries/cmsis/cm3/device_support/startup/mdk/: startup_gw1ns4c.s
  group middleware
    ../../../library/middlewares/uart/: uart.c
    ../../../library/middlewares/gpio/: gpio.c
  group freertos
    ../../../library/middlewares/3rd_party/freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../library/middlewares/3rd_party/freertos/portable/MemMang/: heap_4.c
    ../../../library/middlewares/3rd_party/freertos/portable/MDK/cm3/: port.c
