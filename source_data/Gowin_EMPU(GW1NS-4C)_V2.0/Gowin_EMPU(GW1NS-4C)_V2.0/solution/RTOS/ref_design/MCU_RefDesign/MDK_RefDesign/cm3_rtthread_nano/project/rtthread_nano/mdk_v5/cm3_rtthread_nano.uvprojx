# Keil uVision project cm3_rtthread_nano.uvprojx, settings and files
target cm3_rtthread_nano (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: cm3_rtthread_nano +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o cm3_rtthread_nano.bin .\Objects\cm3_rtthread_nano.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\library\libraries\cmsis\cm3\core_support\mdk;..\..\..\library\libraries\cmsis\cm3\device_support;..\..\..\library\libraries\drivers\inc;..\..\..\library\middlewares\uart;..\..\..\library\middlewares\gpio;..\..\..\library\middlewares\3rd_party\rtthread_nano\bsp\cm3;..\..\..\library\middlewares\3rd_party\rtthread_nano\components\finsh;..\..\..\library\middlewares\3rd_party\rtthread_nano\include;..\..\..\library\middlewares\3rd_party\rtthread_nano\include\libc;..\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ../src/: gw1ns4c_it.c main.c
  group driver
    ../../../library/libraries/drivers/src/: gw1ns4c_gpio.c gw1ns4c_uart.c
  group cmsis
    ../../../library/libraries/cmsis/cm3/core_support/mdk/: core_cm3.c
    ../../../library/libraries/cmsis/cm3/device_support/: system_gw1ns4c.c
    ../../../library/libraries/cmsis/cm3/device_support/startup/mdk/: startup_gw1ns4c.s
  group middleware
    ../../../library/middlewares/uart/: uart.c
    ../../../library/middlewares/gpio/: gpio.c
  group rtthread_nano
    ../../../library/middlewares/3rd_party/rtthread_nano/bsp/cm3/drivers/: board.c
    ../../../library/middlewares/3rd_party/rtthread_nano/components/finsh/: cmd.c finsh_port.c msh.c shell.c
    ../../../library/middlewares/3rd_party/rtthread_nano/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../../library/middlewares/3rd_party/rtthread_nano/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../../../library/middlewares/3rd_party/rtthread_nano/components/device/: device.c
