# Keil uVision project ucos_iii.uvprojx, settings and files
target ucos_iii (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: ucos_iii +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ucos_iii.bin .\Objects\ucos_iii.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\library\libraries\cmsis\cm3\core_support\mdk;..\..\..\library\libraries\cmsis\cm3\device_support;..\..\..\library\libraries\drivers\inc;..\..\..\library\middlewares\uart;..\..\..\library\middlewares\gpio;..\..\..\library\middlewares\3rd_party\ucos_iii\BSP;..\..\..\library\middlewares\3rd_party\ucos_iii\CONFIG;..\..\..\library\middlewares\3rd_party\ucos_iii\CPU;..\..\..\library\middlewares\3rd_party\ucos_iii\CPU\cm3\MDK;..\..\..\library\middlewares\3rd_party\ucos_iii\LIB;..\..\..\library\middlewares\3rd_party\ucos_iii\OS\Source;..\..\..\library\middlewares\3rd_party\ucos_iii\OS\Ports\cm3\Generic\MDK;..\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ../src/: gw1ns4c_it.c led.c main.c printf.c task_app.c
  group driver
    ../../../library/libraries/drivers/src/: gw1ns4c_gpio.c gw1ns4c_uart.c gw1ns4c_misc.c
  group cmsis
    ../../../library/libraries/cmsis/cm3/core_support/mdk/: core_cm3.c
    ../../../library/libraries/cmsis/cm3/device_support/: system_gw1ns4c.c
    ../../../library/libraries/cmsis/cm3/device_support/startup/mdk/: startup_gw1ns4c.s
  group middleware
    ../../../library/middlewares/gpio/: gpio.c
    ../../../library/middlewares/uart/: uart.c
  group ucos_iii
    ../../../library/middlewares/3rd_party/ucos_iii/BSP/: bsp.c
    ../../../library/middlewares/3rd_party/ucos_iii/CONFIG/: os_app_hooks.c
    ../../../library/middlewares/3rd_party/ucos_iii/CPU/: cpu_core.c
    ../../../library/middlewares/3rd_party/ucos_iii/CPU/cm3/MDK/: cpu_c.c cpu_a.asm
    ../../../library/middlewares/3rd_party/ucos_iii/LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../../library/middlewares/3rd_party/ucos_iii/LIB/Ports/cm3/MDK/: lib_mem_a.asm
    ../../../library/middlewares/3rd_party/ucos_iii/OS/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../../../library/middlewares/3rd_party/ucos_iii/OS/Ports/cm3/Generic/MDK/: os_cpu_c.c os_cpu_a.s
