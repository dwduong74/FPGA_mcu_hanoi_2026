# Keil uVision project printf.uvprojx, settings and files
target printf (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: printf +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o printf .\Objects\printf.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CM3_50MHZ_FREQ
  c include: ..\..\..\library\libraries\cmsis\cm3\core_support\mdk;..\..\..\library\libraries\cmsis\cm3\device_support;..\..\..\library\libraries\drivers\inc;..\..\..\library\middlewares\uart;..\..\..\library\middlewares\spi_flash;..\inc
  memory RVCT1: ROM 0x40002400 size 0x2000
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\Objects\printf.sct
  group user
    ../src/: gw1ns4c_it.c main.c ram_func.c
  group driver
    ../../../library/libraries/drivers/src/: gw1ns4c_uart.c
  group cmsis
    ../../../library/libraries/cmsis/cm3/device_support/: system_gw1ns4c.c
    ../../../library/libraries/cmsis/cm3/device_support/startup/mdk/: startup_gw1ns4c.s
    ../../../library/libraries/cmsis/cm3/core_support/mdk/: core_cm3.c
  group middleware
    ../../../library/middlewares/uart/: uart.c
    ../../../library/middlewares/uart/mdk/: retarget.c
    ../../../library/middlewares/spi_flash/: spi_flash.c
